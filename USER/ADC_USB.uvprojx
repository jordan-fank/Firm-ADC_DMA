# Keil uVision project ADC_USB.uvprojx, settings and files
target ADC_USB (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_USB +hex
  AfterMake: .\run_size_bar.bat
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL,USE_USB_OTG_FS,ARM_MATH_LOOPUNROLL
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\USB\USB_BOARD;..\USB\USB_CDC\inc;..\USB\USB_DRIVE\inc;..\USB\USB_UB\inc;..\USB\USB_USER\inc;..\APP;..\SERVICE;..\PLATFORM;..\IMPLEMENT;..\VENDOR;..\CMSIS_DSP\Include;..\CMSIS_DSP\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group APP
    ../APP/: app_main.c app_main.h
  group SERVICE
    ../SERVICE/: adc_stream_service.c adc_stream_service.h adc_fir.c adc_fir.h adc_fir_coeffs.h
  group PLATFORM
    ../PLATFORM/: platform_status.h platform_adc_stream.h platform_byte_stream.h platform_usb_device.h platform_board.h
  group IMPLEMENT
    ../IMPLEMENT/: impl_stm32_board.c impl_stm32_debug_uart.c impl_stm32_debug_uart.h impl_stm32_encoder_adc.c impl_stm32_encoder_adc.h impl_usb_cdc_device.c impl_usb_cdc_device.h impl_usb_cdc_stream.c impl_usb_cdc_stream.h
  group VENDOR
    ../VENDOR/: vendor_stm32_encoder_adc.c vendor_stm32_encoder_adc.h vendor_usb_cdc.c vendor_usb_cdc.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s core_cm4.h core_cm4_simd.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group USB_BOARD
    ../USB/USB_BOARD/: stm324xg_eval.c stm324xg_eval.h
  group USB_CDC
    ../USB/USB_CDC/inc/: usbd_cdc_core.h
    ../USB/USB_CDC/src/: usbd_cdc_core.c
  group USB_DRIVE
    ../USB/USB_DRIVE/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../USB/USB_DRIVE/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_UB
    ../USB/USB_UB/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
    ../USB/USB_UB/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_USER
    ../USB/USB_USER/inc/: usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
    ../USB/USB_USER/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group CMSIS_DSP
    ../CMSIS_DSP/Source/: arm_fir_q15.c arm_fir_init_q15.c
software components: CMSIS:CORE 5.6.0
